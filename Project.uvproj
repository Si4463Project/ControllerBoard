# Keil uVision project Project.uvproj, settings and files
target STM32303C-EVAL (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Project
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F30X USE_STM32303C_EVAL
  c misc: --c99
  c include: .\Libraries\CMSIS\Device\ST\STM32F30x\Include;.\Libraries\STM32F30x_StdPeriph_Driver\inc;.\Utilities\STM32_EVAL\Common;.\Utilities\STM32_EVAL\STM32303C_EVAL;.\Libraries\STM32F30x_CPAL_Driver\inc;.\;.\Libraries\Drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group MDK-ARM
    ./Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group StdPeriph_Drivers
    ./Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_dma.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c
  group STM32_EVAL
    ./Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
  group USER
    ./: main.c stm32f30x_it.c main.h stm32f30x_conf.h stm32f30x_it.h
  group Drivers
    ./Libraries/Drivers/: tw88.c ar1100.c
